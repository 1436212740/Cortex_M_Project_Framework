# Keil uVision project STM32-DEMO.uvprojx, settings and files
target USART1-DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wirter +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\stm32f10x_it;.\CMSIS;.\FWlib\inc;..\Core;..\Core\inc;..\BottomDrive;..\Apply;..\Loop;..\BottomDrive\Led;..\Apply\Control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./stm32f10x_it/: stm32f10x_it.c
    ../Loop/: main.c
  group FWlib
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_i2c.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Core
    ../Core/src/: gpio.c time.c uart.c
  group BottomDrive
    ../BottomDrive/Led/: led.c
  group Control
    ../Apply/Control/: VoltCalculate.c
  group Loop
    ../Loop/: Loop.c Loop_it.c
